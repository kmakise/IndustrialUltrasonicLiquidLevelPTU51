# Keil uVision project Project.uvprojx, settings and files
target BTB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BTB +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc;..\uC-CPU;..\uC-LIB;..\uCOS-II\Ports;..\uCOS-II\Source;..\User\SPI_SD_Card;..\User\FATFS_V0.09\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c
  group DwinGui
    ../User/: Disp.c
  group HardwareDriver
    ../User/: Calc.c CRC.c FM25CL64.c Timer.c FlowMeterHandle.c ModBusProtocol.c memory.c pcf8563.c ADC.c Delay_IO_NVIC_Init.c COM.c Relay.c PTU5X.c
  group StdPeriph_Driver
    ../Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_sdio.c stm32f10x_iwdg.c stm32f10x_dac.c stm32f10x_spi.c stm32f10x_exti.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group uCOS-CPU
    ../uC-CPU/: cpu_c.c cpu_a.asm
  group uCOS-LIB
    ../uC-LIB/: lib_ascii.c lib_mem.c lib_str.c
  group uCOS-II
    ../uCOS-II/Ports/: os_cpu_c.c os_cpu_a.asm os_dbg.c
  group uCOS-SOURCE
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cfg.h ucos_ii.h app_cfg.h
  group SPI_SD_Card
    ../User/SPI_SD_Card/: SPI_MSD0_Driver.c SPI_MSD0_Driver.h FATFS.h FATFS.c
  group FATFS
    ../User/FATFS_V0.09/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../User/FATFS_V0.09/src/option/: ccsbcs.c
software components: CMSIS:CORE 5.4.0
